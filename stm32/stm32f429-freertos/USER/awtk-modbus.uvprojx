# Keil uVision project awtk-modbus.uvprojx, settings and files
target modbus (ARM-ADS)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: awtk +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,WITH_OS_MEM,WITH_FS_MT
  c misc: --gnu
  c include: ..\CORE;..\OBJ;..\USER;..\HALLIB\STM32F4xx_HAL_Driver\Inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\SDRAM;..\HARDWARE\KEY;..\HARDWARE\SDIO;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\MALLOC;..\USMART;..\FATFS\exfuns;..\FATFS\src;..\TEXT;..\HARDWARE\NAND;..\HARDWARE\TOUCH;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\awtk\src\ext_widgets;..\awtk;..\awtk\src;..\awtk\3rd;..\awtk\3rd\nanovg\base;..\awtk\3rd\nanovg;..\awtk\3rd\agge;..\awtk\3rd\libunibreak;..\awtk-port;.\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\APP\led;.\Public;.\APP\beep;.\APP\smg;.\APP\key;.\APP\exti;.\APP\time;.\APP\pwm;.\APP\iwdg;.\APP\wwdg;.\APP\input;.\APP\touch_key;.\APP\wkup;.\APP\adc;.\APP\adc_temp;.\APP\dac;.\APP\pwm_dac;.\APP\dma;.\APP\rtc;.\APP\24Cxx;.\APP\iic;.\APP\ds18b20;.\APP\hwjs;.\APP\rs485;.\APP\can;.\APP\tftlcd;.\APP\spi;.\APP\nrf24l01;.\APP\dht11;.\APP\oled;.\APP\RC522;.\APP\Tetris;.\APP\ball;.\APP\touch;.\APP\snake;..\..\FreeRTOS\Source\include;..\..\FreeRTOS\Source;..\..\FreeRTOS\Source\portable\RVDS\ARM_CM7\r0p1;..\..\..\..\awtk\src;..\..\..\src;..\..\modbus_app;..\..\..\..\awtk-fs-adapter\src;..\..\platform;..\FATFS\source
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: core_cm4.h cmsis_armcc.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f429xx.s
  group HALLIB
    ../HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_sdram.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_nand.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SDRAM/: sdram.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/NAND/: nand.c ftl.c
    ../HARDWARE/TOUCH/: ctiic.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
  group platform
    ../../../../awtk/src/platforms/common/: sys_tick_handler.c
    ../../../../awtk/src/platforms/freertos/: mutex.c rtos.c semaphore.c thread.c
    ../../../../awtk/src/platforms/raw/: cond_var_null.c dl_null.c fs_os.c
    ../../platform/: assert.c platform.c serial_helper.c sys_tick.c uart_hal.c memory_freertos.c fs_test.c
    ../../../../awtk-fs-adapter/src/: fs_os_fatfs.c fs_mt.c
  group freertos
    ../../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c FreeRTOSConfig.h
    ../../FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group tkc
    ../../../../awtk/src/tkc/: action_darray_thread.c action_queue.c action_thread.c action_thread_pool.c asset_info.c async.c buffer.c cmd_args.c color.c color_parser.c compressor.c cond_var.c crc.c darray.c data_reader.c data_reader_factory.c data_reader_file.c data_reader_mem.c data_writer.c data_writer_factory.c data_writer_file.c data_writer_wbuffer.c date_time.c easing.c emitter.c event.c event_source.c event_source_fd.c event_source_idle.c event_source_manager.c event_source_manager_default.c event_source_timer.c fs.c fscript.c func_call_parser.c hash_table.c idle_info.c idle_manager.c int_str.c iostream.c istream.c log.c matrix.c mem.c mutex_nest.c named_value.c object.c object_array.c object_compositor.c object_date_time.c object_default.c object_locker.c object_rbuffer.c object_typed_array.c object_wbuffer.c ostream.c path.c plugin_manager.c qaction.c rect.c ring_buffer.c rlog.c rom_fs.c serial_helper.c sha256.c slist.c socket_helper.c socket_pair.c state_machine.c str.c str_str.c time_now.c timer_info.c timer_manager.c tokenizer.c typed_array.c url.c utf8.c utils.c value.c value_desc.c waitable_action_darray.c waitable_action_queue.c waitable_ring_buffer.c wstr.c
  group streams
    ../../../../awtk/src/streams/: stream_factory.c
    ../../../../awtk/src/streams/serial/: iostream_serial.c istream_serial.c ostream_serial.c
  group service
    ../../../../awtk/src/service/: client.c service.c
  group modbus
    ../../../src/: modbus_client.c modbus_common.c modbus_memory.c modbus_memory_default.c modbus_service.c modbus_service_rtu.c modbus_service_tcp.c
  group modbus_app
    ../../modbus_app/: modbus_app.c modbus_memory_custom.c
  group fatfs
    ../FATFS/source/: ff.c ffunicode.c diskio.c
    ../FATFS/exfuns/: exfuns.c
