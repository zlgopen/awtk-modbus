# Keil uVision project awtk-modbus.uvprojx, settings and files
target modbus (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,WITH_WCSXXX
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\APP\led;.\Public;.\APP\beep;.\APP\smg;.\APP\key;.\APP\exti;.\APP\time;.\APP\pwm;.\APP\iwdg;.\APP\wwdg;.\APP\input;.\APP\touch_key;.\APP\wkup;.\APP\adc;.\APP\adc_temp;.\APP\dac;.\APP\pwm_dac;.\APP\dma;.\APP\rtc;.\APP\24Cxx;.\APP\iic;.\APP\ds18b20;.\APP\hwjs;.\APP\rs485;.\APP\can;.\APP\tftlcd;.\APP\spi;.\APP\nrf24l01;.\APP\dht11;.\APP\oled;.\APP\RC522;.\APP\Tetris;.\APP\ball;.\APP\touch;.\APP\snake;..\FreeRTOS\Source\include;..\FreeRTOS\Source;..\FreeRTOS\Source\portable\RVDS\ARM_CM7\r0p1;..\..\..\awtk\src;..\..\src;..\modbus_app;..\platform\stm32f103
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_wwdg.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_can.c stm32f10x_fsmc.c stm32f10x_spi.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group APP
    ./APP/led/: led.c
    ./APP/tftlcd/: tftlcd.c
    ./APP/time/: time.c
    ./APP/key/: key.c
    ./APP/24Cxx/: 24cxx.c
    ./APP/iic/: iic.c
    ./APP/touch/: touch.c
    ./APP/rtc/: rtc.c
    ./APP/spi/: spi.c
  group Public
    ./Public/: system.c usart.c
  group platform
    ../../../awtk/src/platforms/common/: sys_tick_handler.c
    ../../../awtk/src/platforms/freertos/: mutex.c rtos.c semaphore.c thread.c
    ../../../awtk/src/platforms/raw/: cond_var_null.c dl_null.c fs_os.c
    ../platform/: assert.c platform.c serial_helper.c uart_hal.c
    ../platform/stm32f103/: SysTick.c
  group freertos
    ../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c FreeRTOSConfig.h
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group tkc
    ../../../awtk/src/tkc/: action_darray_thread.c action_queue.c action_thread.c action_thread_pool.c asset_info.c async.c buffer.c cmd_args.c color.c color_parser.c compressor.c cond_var.c crc.c darray.c data_reader.c data_reader_factory.c data_reader_file.c data_reader_mem.c data_writer.c data_writer_factory.c data_writer_file.c data_writer_wbuffer.c date_time.c easing.c emitter.c event.c event_source.c event_source_fd.c event_source_idle.c event_source_manager.c event_source_manager_default.c event_source_timer.c fs.c fscript.c func_call_parser.c hash_table.c idle_info.c idle_manager.c int_str.c iostream.c istream.c log.c matrix.c mem.c mutex_nest.c named_value.c object.c object_array.c object_compositor.c object_date_time.c object_default.c object_locker.c object_rbuffer.c object_typed_array.c object_wbuffer.c ostream.c path.c plugin_manager.c qaction.c rect.c ring_buffer.c rlog.c rom_fs.c serial_helper.c sha256.c slist.c socket_helper.c socket_pair.c state_machine.c str.c str_str.c time_now.c timer_info.c timer_manager.c tokenizer.c typed_array.c url.c utf8.c utils.c value.c value_desc.c waitable_action_darray.c waitable_action_queue.c waitable_ring_buffer.c wstr.c
  group streams
    ../../../awtk/src/streams/: stream_factory.c
    ../../../awtk/src/streams/serial/: iostream_serial.c istream_serial.c ostream_serial.c
  group service
    ../../../awtk/src/service/: client.c service.c
  group modbus
    ../../src/: modbus_client.c modbus_common.c modbus_memory.c modbus_memory_default.c modbus_service.c modbus_service_rtu.c modbus_service_tcp.c
  group modbus_app
    ../modbus_app/: modbus_app.c modbus_memory_custom.c
