# Keil uVision project awtk-modbus.uvprojx, settings and files
target modbus (ARM-ADS)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H743xx,MPL_LOG_NDEBUG=1,EMPL,MPU9250,EMPL_TARGET_STM32F4,WITH_OS_MEM
  c misc: --gnu
  c include: ..\CORE;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HALLIB\STM32H7xx_HAL_Driver\Inc;..\USMART;..\MALLOC;..\HARDWARE\TOUCH;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\MPU;..\HARDWARE\LCD;..\HARDWARE\SDRAM;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\HARDWARE\PCF8574;..\HARDWARE\QSPI;..\HARDWARE\W25QXX;..\HARDWARE\SPI;..\HARDWARE\SDMMC;..\HARDWARE\NAND;..\HARDWARE\QSPI;..\HARDWARE\W25QXX;..\FATFS\exfuns;..\FATFS\source;..\awtk\src\ext_widgets;..\awtk;..\awtk\src;..\awtk\3rd;..\awtk\3rd\nanovg\base;..\awtk\3rd\nanovg;..\awtk\3rd\agge;..\awtk\3rd\libunibreak;..\awtk-port;.\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\APP\led;.\Public;.\APP\beep;.\APP\smg;.\APP\key;.\APP\exti;.\APP\time;.\APP\pwm;.\APP\iwdg;.\APP\wwdg;.\APP\input;.\APP\touch_key;.\APP\wkup;.\APP\adc;.\APP\adc_temp;.\APP\dac;.\APP\pwm_dac;.\APP\dma;.\APP\rtc;.\APP\24Cxx;.\APP\iic;.\APP\ds18b20;.\APP\hwjs;.\APP\rs485;.\APP\can;.\APP\tftlcd;.\APP\spi;.\APP\nrf24l01;.\APP\dht11;.\APP\oled;.\APP\RC522;.\APP\Tetris;.\APP\ball;.\APP\touch;.\APP\snake;..\..\FreeRTOS\Source\include;..\..\FreeRTOS\Source;..\..\FreeRTOS\Source\portable\RVDS\ARM_CM7\r0p1;..\..\..\..\awtk\src;..\..\..\src;..\..\modbus_app;..\..\..\..\awtk-fs-adapter\src;..\..\platform
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group USER
    ./: main.c stm32h7xx_it.c system_stm32h7xx.c stm32h7xx_hal_msp.c
  group CORE
    ../CORE/: core_cm7.h cmsis_armcc.h cmsis_compiler.h startup_stm32h743xx.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group HALLIB
    ../HALLIB/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sram.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_qspi.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_nand.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/MPU/: mpu.c
    ../HARDWARE/SDRAM/: sdram.c
    ../HARDWARE/LCD/: lcd.c ltdc.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/PCF8574/: pcf8574.c
    ../HARDWARE/SDMMC/: sdmmc_sdcard.c
    ../HARDWARE/NAND/: ftl.c nand.c nandtester.c
    ../HARDWARE/QSPI/: qspi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/TOUCH/: ctiic.c ft5206.c gt9147.c touch.c ott2001a.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c fattester.c
    ../FATFS/source/: diskio.c ff.c ffsystem.c ffunicode.c
  group README
    ../: readme.txt
  group platform
    ../../../../awtk/src/platforms/common/: sys_tick_handler.c
    ../../../../awtk/src/platforms/freertos/: mutex.c rtos.c semaphore.c thread.c
    ../../../../awtk/src/platforms/raw/: cond_var_null.c dl_null.c fs_os.c
    ../../platform/: assert.c platform.c serial_helper.c sys_tick.c uart_hal.c memory_freertos.c fs_test.c
    ../../../../awtk-fs-adapter/src/: fs_os_fatfs.c fs_mt.c
  group freertos
    ../../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c FreeRTOSConfig.h
    ../../FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group tkc
    ../../../../awtk/src/tkc/: action_darray_thread.c action_queue.c action_thread.c action_thread_pool.c asset_info.c async.c buffer.c cmd_args.c color.c color_parser.c compressor.c cond_var.c crc.c darray.c data_reader.c data_reader_factory.c data_reader_file.c data_reader_mem.c data_writer.c data_writer_factory.c data_writer_file.c data_writer_wbuffer.c date_time.c easing.c emitter.c event.c event_source.c event_source_fd.c event_source_idle.c event_source_manager.c event_source_manager_default.c event_source_timer.c fs.c fscript.c func_call_parser.c hash_table.c idle_info.c idle_manager.c int_str.c iostream.c istream.c log.c matrix.c mem.c mutex_nest.c named_value.c object.c object_array.c object_compositor.c object_date_time.c object_default.c object_locker.c object_rbuffer.c object_typed_array.c object_wbuffer.c ostream.c path.c plugin_manager.c qaction.c rect.c ring_buffer.c rlog.c rom_fs.c serial_helper.c sha256.c slist.c socket_helper.c socket_pair.c state_machine.c str.c str_str.c time_now.c timer_info.c timer_manager.c tokenizer.c typed_array.c url.c utf8.c utils.c value.c value_desc.c waitable_action_darray.c waitable_action_queue.c waitable_ring_buffer.c wstr.c
  group streams
    ../../../../awtk/src/streams/: stream_factory.c
    ../../../../awtk/src/streams/serial/: iostream_serial.c istream_serial.c ostream_serial.c
  group service
    ../../../../awtk/src/service/: client.c service.c
  group modbus
    ../../../src/: modbus_client.c modbus_common.c modbus_memory.c modbus_memory_default.c modbus_service.c modbus_service_rtu.c modbus_service_tcp.c
  group modbus_app
    ../../modbus_app/: modbus_app.c modbus_memory_custom.c
